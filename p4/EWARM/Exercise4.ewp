# IAR project Exercise4.ewp, settings and files
configuration STM32746G_DISCOVERY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCIncludePath2: ..\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32746G_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ./: startup_stm32f746xx.s
  group Source
    ../Src/: bsp.c bsp.h hw.h main.c pot.c pot.h project.h ringbuff.c ringbuff.h setup.c setup.h stm32f7xx_it.c stm32f7xx_it.h system_stm32f7xx.c uart.c uart.h
