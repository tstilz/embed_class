<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\p0\EWARM\Exercise0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\p1\EWARM\Exercise1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\p2\EWARM\Exercise2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\s2\EWARM\Exercise2_sol.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\p3\EWARM\Exercise3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\p4\EWARM\Exercise4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\p5\AppCode\iar-no-src\Exercise5.ewp</path>
  </project>
  <batchBuild/>
</workspace>


